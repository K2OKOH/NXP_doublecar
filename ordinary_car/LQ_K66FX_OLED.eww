<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LQ_K66FX_OLED.ewp</path>
    </project>
    <batchBuild />
</workspace>
